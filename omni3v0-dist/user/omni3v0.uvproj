# Keil uVision project omni3v0.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: omni3v0 +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c misc: --c99
  c include: ..\board\led;..\board\sram;..\ntshell;..\system\can;..\system\delay;..\system\sys;..\system\usart;..\system\xprintf;..\user
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group system
    ../system/sys/: sys.c
    ../system/delay/: delay.c
    ../system/can/: can.c
    ../system/usart/: usart.c
    ../system/xprintf/: xprintf.c
  group board
    ../board/led/: led.c
    ../board/sram/: sram.c
  group ntshell
    ../ntshell/: ntlibc.c ntopt.c ntshell.c ntshell_usrcmd.c text_editor.c text_history.c vtrecv.c vtsend.c
  group user
    ./: main.c timer.c
